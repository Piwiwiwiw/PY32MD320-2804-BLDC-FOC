# Keil uVision project Project.uvprojx, settings and files
target Project (6160000::V6.16::ARMCLANG)
  device: PY32MD320x8 Puya
  pack: Puya.PY32Mxxx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: PY32MD320x8,USE_FULL_LL_DRIVER
  c include: ..\Inc;..\..\..\Drivers\PY32MD3xx_HAL_Driver\Inc;..\..\..\Drivers\CMSIS\Device\PY32MD3xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Common
    ../Src/: system_py32md3xx.c
    ./: startup_py32md320xx.s
  group Application/User
    ../Src/: main.c py32md3xx_it.c FOC.c trig_q15_func.c
    ../Inc/: main.h FOC.h py32md3xx_it.h trig_q15_func.h
  group Drivers/PY32MD3xx_HAL_Driver
    ../../../Drivers/PY32MD3xx_HAL_Driver/Src/: py32md3xx_ll_utils.c py32md3xx_ll_adc.c py32md3xx_ll_comp.c py32md3xx_ll_crc.c py32md3xx_ll_dma.c py32md3xx_ll_exti.c py32md3xx_ll_gpio.c py32md3xx_ll_i2c.c py32md3xx_ll_led.c py32md3xx_ll_lptim.c py32md3xx_ll_pwr.c py32md3xx_ll_rcc.c py32md3xx_ll_rtc.c py32md3xx_ll_spi.c py32md3xx_ll_tim.c py32md3xx_ll_usart.c
    ../../../Drivers/PY32MD3xx_HAL_Driver/Inc/: py32md3xx_ll_adc.h py32md3xx_ll_bus.h py32md3xx_ll_comp.h py32md3xx_ll_cortex.h py32md3xx_ll_crc.h py32md3xx_ll_dma.h py32md3xx_ll_exti.h py32md3xx_ll_flash.h py32md3xx_ll_gpio.h py32md3xx_ll_i2c.h py32md3xx_ll_iwdg.h py32md3xx_ll_lptim.h py32md3xx_ll_pwr.h py32md3xx_ll_rcc.h py32md3xx_ll_rtc.h py32md3xx_ll_spi.h py32md3xx_ll_system.h py32md3xx_ll_tim.h py32md3xx_ll_usart.h py32md3xx_ll_utils.h py32md3xx_ll_wwdg.h
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 6.1.1
